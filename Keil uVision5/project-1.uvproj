# Keil uVision project project-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: project-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: task4_1.asm task4_3.asm add.asm

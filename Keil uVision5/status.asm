SW1 EQU P1.7
	ORG 0H
		MOV TMOD, #20H
		MOV TH1, #-3
		MOV SCON, #50H
		SETB TR1
		SETB SW1
		S1: JB SW1, NEXT
		MOV DPTR, #MESS1
		FN: CLR A
		MOVC A, @A+DPTR
		JZ S1
		ACALL SENDCOM
		INC DPTR
		SJMP FN
		NEXT: MOV DPTR, #MESS2
		LN: CLR A
		MOVC A, @A+DPTR
		JZ S1
		ACALL SENDCOM
		INC DPTR
		SJMP LN
		
		SENDCOM: MOV SBUF,A
		HERE: JNB TI, HERE
		CLR TI
		RET
		
		MESS1: DB "NO", 0
		MESS2: DB "YES", 0
END
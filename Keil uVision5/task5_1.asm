ORG 0000H
	MOV DPTR, #200H
	MOV R0, #0
	LJMP MAIN
	ORG 000BH
		CPL P2.1
		RETI
		ORG 0030H
			MAIN: MOV TMOD, #01H
			MOV TH0, #89H
			MOV TL0, #5FH
			MOV IE, #10000010B
			SETB TR0
			BACK: CLR A
			MOVC A, @A+DPTR
			MOV P0, A
			MOV A, P0
			MOV P1, A
			INC DPTR
			INC R0
			CJNE R0, #9,  BACK
			MOV DPTR, #200H
			SJMP BACK
	ORG 200H
		MYDATA: DB "21BCE2067"
END